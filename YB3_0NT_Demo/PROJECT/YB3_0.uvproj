# Keil uVision project YB3_0.uvproj, settings and files
target YB3_0 (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x3FFF) CLOCK(13000000) CPUTYPE(ARM926EJ-S) FPU(ANSI)
  output: YB30_Demo
  AfterMake: c:\Keil\ARM\BIN40\fromelf.exe --bin -o ..\PROJECT\YB30_Demo.bin ..\OBJ\YB30_Demo.axf
  c flags: Optim=1
  c define: USEMODE PUBMODE __STRG_NOR  __STRG_SD __UCOS __STRG_NAND
  c include: ..\SRC;..\SRC\AppDriver;..\SRC\LCD;..\SRC\OS;..\SRC\Protocol;..\SRC\SYSTEM;..\SRC\TASK;..\SRC\UI;..\SRC\Include;..\SRC\Common;..\SRC\SD;..\SRC\JG;..\SRC\Common
  asm define: __FLASHMODE
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x80000000 size 0x4000000
  memory RVCT9: RAM 0x8000000 size 0x40000
  scatter file: .\ExSDRAM.sct
  group UCOS
    ../SRC/OS/: OS_CORE.C Os_cpu_c.c OS_FLAG.C OS_MBOX.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C Os_cpu_a.s
  group System
    ../SRC/SYSTEM/: main.c target.c Startup.s vicControl.s
  group HeadFile
    ../SRC/SYSTEM/: config.h
    ../SRC/OS/: OS_CFG.H
    ../SRC/AppDriver/: GPIO.h KBMacro.h
    ../SRC/TASK/: JZGlobal.h JZStructure.h DEFConfig.h
    ../SRC/Protocol/: AdjustMacro.h
  group AppDriver
    ../SRC/AppDriver/: DS2460.c GPIO.c I2C1.c I2C2.c Keyboard.c LCDApp.c NANDFlash.c NORFlash.c PCF8563.c SHA.c StorageApp.c TDC256.c Timer0.c Uart2.c Uart3.c Uart5.c WDT.c DS18B20.c W5100.c W5100App.c IRQ.c Timer1h.c Uart1.c
  group LCD
    ../SRC/LCD/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C lcddrive.c loadbit.c spline.c windows.c
  group Task
    ../SRC/TASK/: Common.c WT_Task.c
    ../SRC/Task/: Task_TiPo.c Task_Uart5.c Task_JG0.c Task_JG1.c Task_JG2.c Task_Data_JG.c Task_Uart5_Senddata.c Task_Checknet.c Task_SendUart1.c Task_Uart5_Senddata_NEW.c Task_JG3.c sort.c TaskMatchSend.c
  group Common
    ../SRC/Common/: RD_data.c crc.c crc.h CMD.c FW.c
  group SD
    ../SRC/SD/: sdcmd.c sdcrc.c sddriver.c sdhal.c sdspihal.c
  group JG
    ../SRC/JG/: JG.c
  group Protocol
    ../SRC/Protocol/: Protocol.c
target YB3_0_TEST (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: as above
  output: YB30_Demo +hex
  AfterMake: c:\Keil\ARM\BIN40\fromelf.exe --bin -o ..\PROJECT\YB30_Demo_Test.bin ..\OBJ\YB30_Demo.axf
  c flags: Optim=1
  c define: USEMODE PUBMODE __STRG_NOR  __STRG_SD __UCOS __STRG_NAND SIM_SOFTWARE
  c include: as above
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x80000000 size 0x4000000
  memory RVCT9: RAM 0x8000000 size 0x40000
  scatter file: .\ExSDRAM.sct
target abc (ARM-ADS)
  device: LPC3250 NXP (founded by Philips)
  cpu: as above
  output: YB30_Demo +hex
  AfterMake: as above
  c flags: Optim=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT6: RAM 0x80000000 size 0x4000000
  memory RVCT9: RAM 0x8000000 size 0x40000
  scatter file: .\ExSDRAM.sct
